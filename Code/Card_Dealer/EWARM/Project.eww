<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Card_Dealer.ewp</path>
  </project>
  <batchBuild />
</workspace>
